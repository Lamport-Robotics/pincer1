#include "display.h"

#include <string.h>

/* Classic 5x7 ASCII face, column-major, bit 0 = top row. 0x20..0x7E, then the two extra glyphs. */
static const uint8_t FONT5X7[98][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, /* ' ' */
    {0x00, 0x00, 0x5F, 0x00, 0x00}, /* ! */
    {0x00, 0x07, 0x00, 0x07, 0x00}, /* " */
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, /* # */
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, /* $ */
    {0x23, 0x13, 0x08, 0x64, 0x62}, /* % */
    {0x36, 0x49, 0x55, 0x22, 0x50}, /* & */
    {0x00, 0x05, 0x03, 0x00, 0x00}, /* ' */
    {0x00, 0x1C, 0x22, 0x41, 0x00}, /* ( */
    {0x00, 0x41, 0x22, 0x1C, 0x00}, /* ) */
    {0x14, 0x08, 0x3E, 0x08, 0x14}, /* * */
    {0x08, 0x08, 0x3E, 0x08, 0x08}, /* + */
    {0x00, 0x50, 0x30, 0x00, 0x00}, /* , */
    {0x08, 0x08, 0x08, 0x08, 0x08}, /* - */
    {0x00, 0x60, 0x60, 0x00, 0x00}, /* . */
    {0x20, 0x10, 0x08, 0x04, 0x02}, /* / */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* 0 */
    {0x00, 0x42, 0x7F, 0x40, 0x00}, /* 1 */
    {0x42, 0x61, 0x51, 0x49, 0x46}, /* 2 */
    {0x21, 0x41, 0x45, 0x4B, 0x31}, /* 3 */
    {0x18, 0x14, 0x12, 0x7F, 0x10}, /* 4 */
    {0x27, 0x45, 0x45, 0x45, 0x39}, /* 5 */
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, /* 6 */
    {0x01, 0x71, 0x09, 0x05, 0x03}, /* 7 */
    {0x36, 0x49, 0x49, 0x49, 0x36}, /* 8 */
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 9 */
    {0x00, 0x36, 0x36, 0x00, 0x00}, /* : */
    {0x00, 0x56, 0x36, 0x00, 0x00}, /* ; */
    {0x08, 0x14, 0x22, 0x41, 0x00}, /* < */
    {0x14, 0x14, 0x14, 0x14, 0x14}, /* = */
    {0x00, 0x41, 0x22, 0x14, 0x08}, /* > */
    {0x02, 0x01, 0x51, 0x09, 0x06}, /* ? */
    {0x32, 0x49, 0x79, 0x41, 0x3E}, /* @ */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* A */
    {0x7F, 0x49, 0x49, 0x49, 0x36}, /* B */
    {0x3E, 0x41, 0x41, 0x41, 0x22}, /* C */
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* D */
    {0x7F, 0x49, 0x49, 0x49, 0x41}, /* E */
    {0x7F, 0x09, 0x09, 0x09, 0x01}, /* F */
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, /* G */
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* H */
    {0x00, 0x41, 0x7F, 0x41, 0x00}, /* I */
    {0x20, 0x40, 0x41, 0x3F, 0x01}, /* J */
    {0x7F, 0x08, 0x14, 0x22, 0x41}, /* K */
    {0x7F, 0x40, 0x40, 0x40, 0x40}, /* L */
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, /* M */
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, /* N */
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* O */
    {0x7F, 0x09, 0x09, 0x09, 0x06}, /* P */
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, /* Q */
    {0x7F, 0x09, 0x19, 0x29, 0x46}, /* R */
    {0x46, 0x49, 0x49, 0x49, 0x31}, /* S */
    {0x01, 0x01, 0x7F, 0x01, 0x01}, /* T */
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, /* U */
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, /* V */
    {0x3F, 0x40, 0x38, 0x40, 0x3F}, /* W */
    {0x63, 0x14, 0x08, 0x14, 0x63}, /* X */
    {0x07, 0x08, 0x70, 0x08, 0x07}, /* Y */
    {0x61, 0x51, 0x49, 0x45, 0x43}, /* Z */
    {0x00, 0x7F, 0x41, 0x41, 0x00}, /* [ */
    {0x02, 0x04, 0x08, 0x10, 0x20}, /* \ */
    {0x00, 0x41, 0x41, 0x7F, 0x00}, /* ] */
    {0x04, 0x02, 0x01, 0x02, 0x04}, /* ^ */
    {0x40, 0x40, 0x40, 0x40, 0x40}, /* _ */
    {0x00, 0x01, 0x02, 0x04, 0x00}, /* ` */
    {0x20, 0x54, 0x54, 0x54, 0x78}, /* a */
    {0x7F, 0x48, 0x44, 0x44, 0x38}, /* b */
    {0x38, 0x44, 0x44, 0x44, 0x20}, /* c */
    {0x38, 0x44, 0x44, 0x48, 0x7F}, /* d */
    {0x38, 0x54, 0x54, 0x54, 0x18}, /* e */
    {0x08, 0x7E, 0x09, 0x01, 0x02}, /* f */
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, /* g */
    {0x7F, 0x08, 0x04, 0x04, 0x78}, /* h */
    {0x00, 0x44, 0x7D, 0x40, 0x00}, /* i */
    {0x20, 0x40, 0x44, 0x3D, 0x00}, /* j */
    {0x7F, 0x10, 0x28, 0x44, 0x00}, /* k */
    {0x00, 0x41, 0x7F, 0x40, 0x00}, /* l */
    {0x7C, 0x04, 0x18, 0x04, 0x78}, /* m */
    {0x7C, 0x08, 0x04, 0x04, 0x78}, /* n */
    {0x38, 0x44, 0x44, 0x44, 0x38}, /* o */
    {0x7C, 0x14, 0x14, 0x14, 0x08}, /* p */
    {0x08, 0x14, 0x14, 0x18, 0x7C}, /* q */
    {0x7C, 0x08, 0x04, 0x04, 0x08}, /* r */
    {0x48, 0x54, 0x54, 0x54, 0x20}, /* s */
    {0x04, 0x3F, 0x44, 0x40, 0x20}, /* t */
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, /* u */
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, /* v */
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, /* w */
    {0x44, 0x28, 0x10, 0x28, 0x44}, /* x */
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, /* y */
    {0x44, 0x64, 0x54, 0x4C, 0x44}, /* z */
    {0x00, 0x08, 0x36, 0x41, 0x00}, /* { */
    {0x00, 0x00, 0x7F, 0x00, 0x00}, /* | */
    {0x00, 0x41, 0x36, 0x08, 0x00}, /* } */
    {0x08, 0x04, 0x08, 0x10, 0x08}, /* ~ */
    {0x00, 0x00, 0x18, 0x00, 0x00}, /* 0x7F: middle dot */
    {0x40, 0x00, 0x40, 0x00, 0x40}, /* 0x80: ellipsis */
};

const uint8_t *display_glyph(uint8_t code)
{
    if (code >= 0x20 && code <= 0x80) return FONT5X7[code - 0x20];
    return FONT5X7['?' - 0x20];
}

/* SSD1309 initialisation. Values follow the datasheet's typical 128x64 setup; no charge pump command (that
 * is an SSD1306 feature, the 1309 panels use an external VCC). */
static const uint8_t INIT_SEQ[] = {
    0xAE,       /* display off */
    0xD5, 0xA0, /* clock divide / oscillator */
    0xA8, 0x3F, /* multiplex 64 */
    0xD3, 0x00, /* display offset */
    0x40,       /* start line 0 */
    0x20, 0x00, /* horizontal addressing mode */
    0xA1,       /* segment remap (column 127 -> SEG0): panel mounted with the connector at the bottom */
    0xC8,       /* COM scan direction remapped */
    0xDA, 0x12, /* COM pins: alternative, no left/right remap */
    0x81, 0x7F, /* contrast */
    0xD9, 0x25, /* pre-charge */
    0xDB, 0x34, /* VCOMH deselect */
    0xA4,       /* display follows RAM */
    0xA6,       /* normal (not inverted) */
    0xAF,       /* display on */
};

void display_init(display_t *d, const display_hw_t *hw)
{
    memset(d, 0, sizeof *d);
    d->hw = hw;
    d->dirty = true;
    if (!hw) return;
    hw->reset();
    hw->cmd(INIT_SEQ, sizeof INIT_SEQ);
}

bool display_present(const display_t *d) { return d->hw != NULL; }

bool display_flush(display_t *d)
{
    static const uint8_t window[] = {0x21, 0x00, 0x7F, 0x22, 0x00, 0x07}; /* column 0..127, page 0..7 */
    if (!d->dirty) return false;
    d->dirty = false;
    if (!d->hw) return false;
    d->hw->cmd(window, sizeof window);
    d->hw->data(d->fb, sizeof d->fb);
    return true;
}

void display_clear(display_t *d)
{
    memset(d->fb, 0, sizeof d->fb);
    d->dirty = true;
}

void display_pixel(display_t *d, int x, int y, bool on)
{
    uint8_t *b;
    if (x < 0 || y < 0 || x >= DISPLAY_W || y >= DISPLAY_H) return;
    b = &d->fb[(y / 8) * DISPLAY_W + x];
    if (on) *b |= (uint8_t)(1u << (y & 7));
    else *b &= (uint8_t)~(1u << (y & 7));
    d->dirty = true;
}

bool display_get_pixel(const display_t *d, int x, int y)
{
    if (x < 0 || y < 0 || x >= DISPLAY_W || y >= DISPLAY_H) return false;
    return (d->fb[(y / 8) * DISPLAY_W + x] >> (y & 7)) & 1;
}

void display_hline(display_t *d, int x0, int x1, int y, bool on)
{
    int x;
    for (x = x0; x <= x1; x++) display_pixel(d, x, y, on);
}

void display_vline(display_t *d, int x, int y0, int y1, bool on)
{
    int y;
    for (y = y0; y <= y1; y++) display_pixel(d, x, y, on);
}

void display_rect(display_t *d, int x, int y, int w, int h, bool on)
{
    if (w <= 0 || h <= 0) return;
    display_hline(d, x, x + w - 1, y, on);
    display_hline(d, x, x + w - 1, y + h - 1, on);
    display_vline(d, x, y, y + h - 1, on);
    display_vline(d, x + w - 1, y, y + h - 1, on);
}

void display_fill_rect(display_t *d, int x, int y, int w, int h, bool on)
{
    int yy;
    for (yy = y; yy < y + h; yy++) display_hline(d, x, x + w - 1, yy, on);
}

/* Next glyph code from a UTF-8 string; advances *s. */
static uint8_t next_code(const char **s)
{
    const uint8_t *p = (const uint8_t *)*s;
    if (p[0] == 0xC2 && p[1] == 0xB7) { *s += 2; return DISPLAY_GLYPH_DOT; }
    if (p[0] == 0xE2 && p[1] == 0x80 && p[2] == 0xA6) { *s += 3; return DISPLAY_GLYPH_ELLIPSIS; }
    if (p[0] >= 0x80) { /* any other multi-byte sequence: one '?' */
        (*s)++;
        while (((const uint8_t *)*s)[0] >= 0x80 && ((const uint8_t *)*s)[0] < 0xC0) (*s)++;
        return '?';
    }
    (*s)++;
    return p[0];
}

size_t display_text_cells(const char *s)
{
    size_t n = 0;
    while (*s) { next_code(&s); n++; }
    return n;
}

static void draw_glyph(display_t *d, int x, int y, const uint8_t *g, bool inverted)
{
    int col, row;
    for (col = 0; col < DISPLAY_CELL_W; col++) {
        uint8_t bits = col < DISPLAY_FONT_W ? g[col] : 0;
        for (row = 0; row < 8; row++) {
            bool on = row < DISPLAY_FONT_H && ((bits >> row) & 1);
            display_pixel(d, x + col, y + row, inverted ? !on : on);
        }
    }
}

int display_text(display_t *d, int x, int y, const char *s, bool inverted)
{
    int n = 0;
    while (*s && x + DISPLAY_FONT_W <= DISPLAY_W) {
        draw_glyph(d, x, y, display_glyph(next_code(&s)), inverted);
        x += DISPLAY_CELL_W;
        n++;
    }
    return n;
}

/* 8x16 from 5x7: columns c0 c1 c1 c2 c2 c3 c3 c4, rows doubled, blank row top and bottom. */
static void draw_glyph_big(display_t *d, int x, int y, const uint8_t *g)
{
    static const uint8_t SRC_COL[DISPLAY_BIG_W] = {0, 1, 1, 2, 2, 3, 3, 4};
    int col, row;
    for (col = 0; col < DISPLAY_BIG_W; col++) {
        uint8_t bits = g[SRC_COL[col]];
        for (row = 0; row < DISPLAY_FONT_H; row++) {
            bool on = (bits >> row) & 1;
            display_pixel(d, x + col, y + 1 + 2 * row, on);
            display_pixel(d, x + col, y + 2 + 2 * row, on);
        }
        display_pixel(d, x + col, y, false);
        display_pixel(d, x + col, y + DISPLAY_BIG_H - 1, false);
    }
}

int display_text_big(display_t *d, int x, int y, const char *s)
{
    int n = 0;
    while (*s && x + DISPLAY_BIG_W <= DISPLAY_W) {
        draw_glyph_big(d, x, y, display_glyph(next_code(&s)));
        x += DISPLAY_BIG_W;
        n++;
    }
    return n;
}
